# Repository 74th/Stack-chan_Takao_Base

## KiCad design Stack-chan_Takao_Base_v121.kicad_pcb

Parts:
C1, C2: 100u; CP_Radial_D6.3mm_P2.50mm
C3, C4: 100u; C_1206_3216Metric
CN1: CON_USB-C-6; Connector_USB-C-Receptacle_TH_6-Pin_Vertical; LCSC C692420
CN2: CON_GROVE; CON_GROVE_V
J1, J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 5.1k; R_0603_1608Metric
R3, R4: 5.1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
SW1: SW_SPDT; SW_SPDT_9x4mm_W2.5mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, CN2.3, J1.2, J2.2, SW1.2 (B), SW1.3 (C)
/SV1: CN2.1, J1.3
/SV2: CN2.2, J2.3
GND: C1.2, C2.2, C3.2, C4.2, CN1.A12 (GND1), CN1.B12 (GND2), CN1.FG, CN2.4, J1.1, J2.1, R1.2, R2.2, R3.2, R4.2
unnamed: CN1.A5 (CC1), R2.1, R4.1
unnamed: CN1.B5 (CC2), R1.1, R3.1
unnamed: CN1.A9 (VBUS1), CN1.B9 (VBUS2), SW1.1 (A)

Board: 2 copper layers, 25.0 x 27.0 mm, 13 parts (2 on the bottom side), 7 nets.

## Commit log

2024-06-16 change USB footprint
